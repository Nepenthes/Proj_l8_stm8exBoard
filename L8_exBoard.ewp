# IAR project L8_exBoard.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: D:\Prj_temp\Proj_l8_stm8exBoard\user; D:\Prj_temp\Proj_l8_stm8exBoard\stdPeriph_drvLib\inc; D:\Prj_temp\Proj_l8_stm8exBoard\stdPeriph_drvLib\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: L8_exBoard.hex
  ILINK.IlinkOutputFile: L8_exBoard.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  group stdPeriph_drvLib
    stdPeriph_drvLib/src/: stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_spi.c stm8s_tim1.c stm8s_uart1.c
  group user
    user/: main.c stm8s_it.c
